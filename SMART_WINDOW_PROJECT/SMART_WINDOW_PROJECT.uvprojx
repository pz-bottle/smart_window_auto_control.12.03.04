# Keil uVision project SMART_WINDOW_PROJECT.uvprojx, settings and files
target SMART_WINDOW (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SMART_WINDOW_PROJECT +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SMART_WINDOW_CORE;..\SMART_WINDOW_FWLIB\inc;..\SMART_WINDOW_FreeRTOS\include;..\SMART_WINDOW_FreeRTOS\portable\RVDS\ARM_CM3;..\SMART_WINDOW_USER;..\SMART_WINDOW_HARDWARE\delay;..\SMART_WINDOW_HARDWARE\dht22;..\SMART_WINDOW_HARDWARE\gsm;..\SMART_WINDOW_HARDWARE\usart;..\SMART_WINDOW_HARDWARE\led;..\SMART_WINDOW_HARDWARE\pwm;..\SMART_WINDOW_HARDWARE\lcd;..\SMART_WINDOW_HARDWARE\beep;..\SMART_WINDOW_HARDWARE\kb;..\SMART_WINDOW_HARDWARE\dust;..\SMART_WINDOW_HARDWARE\toxicgas;..\SMART_WINDOW_HARDWARE\rain;..\SMART_WINDOW_HARDWARE\infrared;..\SMART_WINDOW_HARDWARE\hc_sr;..\SMART_WINDOW_HARDWARE\nrf24l01;..\SMART_WINDOW_HARDWARE\pca9685;..\SMART_WINDOW_HARDWARE\IIC;..\SMART_WINDOW_HARDWARE\flash;..\SMART_WINDOW_HARDWARE\anti_steal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group TASK
    ../SMART_WINDOW_USER/: flash_alarm_task.c rainwiper_task.c read_tempehumid_task.c scankey_task.c stealing_task.c watchdog_for_secure_state_task.c main_task.c
  group USER
    ../SMART_WINDOW_USER/: main.c FreeRTOSConfig.h msgdef.h dp.h window.c stm32f10x_it.c stm32f10x_conf.h system_stm32f10x.c
  group FWLIB
    ../SMART_WINDOW_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../SMART_WINDOW_CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group FreeRTOS
    ../SMART_WINDOW_FreeRTOS/: list.c queue.c tasks.c timers.c
    ../SMART_WINDOW_FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../SMART_WINDOW_FreeRTOS/portable/MemMang/: heap_4.c
  group HARDWARE
    ../SMART_WINDOW_HARDWARE/delay/: delay.c
    ../SMART_WINDOW_HARDWARE/usart/: usart.c
    ../SMART_WINDOW_HARDWARE/gsm/: gsm.c
    ../SMART_WINDOW_HARDWARE/dht22/: dht22.c
    ../SMART_WINDOW_HARDWARE/led/: led.c
    ../SMART_WINDOW_HARDWARE/lcd/: lcd5110.c
    ../SMART_WINDOW_HARDWARE/beep/: beep.c
    ../SMART_WINDOW_HARDWARE/kb/: kb.c
    ../SMART_WINDOW_HARDWARE/dust/: dust.c
    ../SMART_WINDOW_HARDWARE/toxicgas/: toxicgas.c
    ../SMART_WINDOW_HARDWARE/rain/: rain.c
    ../SMART_WINDOW_HARDWARE/infrared/: infrared.c
    ../SMART_WINDOW_HARDWARE/hc_sr/: hc_sr.c
    ../SMART_WINDOW_HARDWARE/pca9685/: PCA9685.c
    ../SMART_WINDOW_HARDWARE/IIC/: myiic.c
    ../SMART_WINDOW_HARDWARE/flash/: flash.c
    ../SMART_WINDOW_HARDWARE/anti_steal/: anti_steal.c
  group DOC
    ./: readme.txt
